Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 6fc5b262-66e9-4a7e-aefe-739de108858a, NumberOfSaves: 82], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Tools_RaptorMaxi_10ScrewsA_0º_90º.ifc
Time: 2026-09-18T09:24:17
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDiscreteAccessory: Specialty Equipment : ROTHOB_Rothoblaas_Tools_RatorMaxi : RAPMAXI_10Screws_A_200x225x237mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_Steel_Red, <Unnamed>
Type - Visibility - Configuration: 9; Hole_01: yes; Hole_02: no; Hole_03: no; Hole_04: no; Hole_05: no; Hole_06: no
Type - Data - InfoScrews: The RAPTOR MAXI plate must be fixed with homogeneous connectors, same type (HBS PLATE, VGS PLATE or VGS) of the same length. The same configuration must be replicated on all plates used on the element to be moved.; LiftingAngleInfo: Check and follow supplier's prescriptions available in the technical datasheet and the manual for addressing lifting angle permitted, depending on the configuration chosen; LiftingCapacityShear: 4000 kg; LiftingCapacityTensile: 8000 kg; MaintenanceDisclaimer: Follow manual's instructions. After visual inspection before each use, if any defect is detected, do not use again. Repairs not permitted; MaximumHoleDiameterforReuse_Drmax: 13.5 mm; MinimumHookThicknessforReuse_cmin: 16.5 mm; ReferenceStandards_EU: REGULATION (EU) 2023/1230; ReferenceStandards_US: OSHA Section 1926.753(e)(2) | ASME BTH01-2023; SuitableScrews: VGS PLATE dn=11 mm, HBS PLATE/HBS PLATE EVO dn=10 mm, VGS dn=11 mm (+ HUS10)
Type - General - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Tools_RaptorMaxi; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 35.51.31.33.61; OmniClassTitle: Other Lifting Appliances and Conveyors; OmniClassVersion: 2006-03-28; ProductInformation: https://www.rothoblaas.com/products/tools-and-machines/transport-and-lifting/raptor-maxi; Revision: 000; UniClass2015Code: Pr_20_29_03_47; UniClass2015Title: Lifting anchors; UniClass2015Version: Products v1.42; Version: 001
Type - Constraints - Default Elevation: 0 mm
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_Steel_Red
Type - Dimensions - Height_d: 237 mm; HoleDiameter_Dh: 13 mm; HookThickness_c: 20 mm; Length_L: 225 mm; Thickness_t: 20 mm; ThicknessBasePlate_s: 15 mm; Width_B: 200 mm; XSpacingHoles_a: 40 mm; YSpacingHoles_b: 46.19 mm
Type - Identity Data - Description: Large rigging device for timber elements; Manufacturer: info@rothoblaas.com; OmniClass Number: 23.27.71.21; Type Name: RAPMAXI_10Screws_A_200x225x237mm
Type - Other - Category: Specialty Equipment; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: CE - Construction products; Color: Red; Constituents: n/a; DurationUnit: Cycles; ExpectedLife: 16000; Family Name: ROTHOB_Rothoblaas_Tools_RatorMaxi; Features: Variable load capacity, self-aligning and certified; Finish: n/a; Grade: n/a; GTIN: 8055598651532; Material: Steel; MinWeight: 7.6 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: RAPMAXI; ModelReference: n/a; Name: Rigging device; NominalHeight: 237 mm; NominalLength: 225 mm; NominalWidth: 200 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 200x225x237 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Red
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_ProductRequirements - Name: Rigging device
Pset_QuantityTakeOff - Reference: RAPMAXI_10Screws_A_200x225x237mm
Constraints - Elevation from Level: 0 mm; Host: Level : 0_Rothoblaas; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Area: 0.0966187 m2; ConnectorAngle: 0 deg; ConnectorAngle_CTRL: 0 deg; HookInclination: 90 deg; HookInclination_CTRL: 90 deg; Volume: 0.0009952 m3
Other - Family: ROTHOB_Rothoblaas_Tools_RatorMaxi; Family and Type: ROTHOB_Rothoblaas_Tools_RatorMaxi: RAPMAXI_10Screws_A_200x225x237mm; InstallationDate: n/a; Type: RAPMAXI_10Screws_A_200x225x237mm; Type Id: 2155947; WarrantyStartDate: n/a
